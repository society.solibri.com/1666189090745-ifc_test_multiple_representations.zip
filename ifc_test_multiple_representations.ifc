Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Coordination View V2.0]
File name: 01_ifcexport_slns_1_ifc2x3.ifc
Time: 2022-03-04T17:38:05
Author: da
Organization: SOFiSTiK AG
Made in: sof_sdai_toolkit
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBeam, Member 11
In: Storey
Material: C 30/37 (EN 1992)
